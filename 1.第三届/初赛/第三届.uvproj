# Keil uVision project 第三届.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 第三届 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: PCF8591.C iic.c main.c my.c
