# Keil uVision project 第十三届模拟.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 第十三届模拟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c my.c iic.c
